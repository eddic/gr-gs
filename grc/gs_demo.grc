<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gs_demo</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constellation</value></param>
<param><key>const_points</key><value>[1,1j,-1j,-1]</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_size</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>Descrambler</key>
<param><key>id</key><value>Descrambler_0</value></param>
<param><key>augmentingLength</key><value>3</value></param>
<param><key>codewordLength</key><value>12</value></param>
<param><key>continuous</key><value>True</value></param>
<param><key>fieldSize</key><value>4</value></param>
<param><key>framingStyle</key><value>Read</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>multiplier</key><value>[1,0,0,1]</value></param>
</block>
<block>
<key>InfiniteAverage</key>
<param><key>id</key><value>InfiniteAverage_0</value></param>
<param><key>decimation</key><value>16</value></param>
<param><key>vectorSize</key><value>window_size</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-4</value></param>
<param><key>reference</key><value>max([abs(number) for number in constellation.points()])</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
<param><key>type</key><value>'SER'</value></param>
<param><key>win_size</key><value>1000</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>window_size</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>189</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/eddie/Desktop/input</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/eddie/Desktop/output</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>window_size</value></param>
<param><key>k</key><value>-10*cmath.log10(baud_rate * samples_per_symbol).real</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>window_size</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>channelNoise</value></param>
<param><key>amp</key><value>0.01</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>constellation</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>constellation</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>excess_bw</key><value>alpha</value></param>
<param><key>samples_per_symbol</key><value>samples_per_symbol</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>window_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(window_size)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>firdesImport</value></param>
<param><key>import</key><value>from gnuradio.filter import firdes</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>firdesImport_0</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>GuidedScrambler</key>
<param><key>id</key><value>guidedScrambler</value></param>
<param><key>augmentingLength</key><value>3</value></param>
<param><key>codewordLength</key><value>12</value></param>
<param><key>constellation</key><value>constellation.points()</value></param>
<param><key>continuous</key><value>True</value></param>
<param><key>divider</key><value>[1,0,0,1]</value></param>
<param><key>fieldSize</key><value>4</value></param>
<param><key>frameLength</key><value>4096</value></param>
<param><key>framingStyle</key><value>Generate</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>selectionMethod</key><value>MSW</value></param>
<param><key>threads</key><value>0</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>matchedFilter</value></param>
<param><key>decim</key><value>samples_per_symbol</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>samp_delay</key><value>taps/2</value></param>
<param><key>taps</key><value>firdes.root_raised_cosine(1.0, baud_rate*samples_per_symbol, baud_rate, alpha, taps)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>noiseAdder</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>PulseGenerator</key>
<param><key>id</key><value>pulseGenerator</value></param>
<param><key>amplitude</key><value>0.8</value></param>
<param><key>baudRate</key><value>baud_rate</value></param>
<param><key>constellation</key><value>constellation.points()</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>phase</key><value>0.0</value></param>
<param><key>samplesPerSymbol</key><value>samples_per_symbol</value></param>
<param><key>shape</key><value>1</value></param>
<param><key>numberOfTaps</key><value>taps</value></param>
<param><key>tags</key><value>False</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Symbol Error Rate"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>window_size</value></param>
<param><key>x_axis_label</key><value>"Frequency (kHz)"</value></param>
<param><key>x_start</key><value>-baud_rate*samples_per_symbol/2000</value></param>
<param><key>x_step</key><value>baud_rate*samples_per_symbol*1.0/(window_size*1000)</value></param>
<param><key>x_units</key><value>"kHz"</value></param>
<param><key>y_axis_label</key><value>"Spectral Density (dBFS/Hz)"</value></param>
<param><key>y_units</key><value>"dB"</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>receivedSignalConstellation</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>SymbolGenerator</key>
<param><key>id</key><value>symbolGenerator</value></param>
<param><key>weightings</key><value>[1, 1, 1, 1]</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>throttle</value></param>
<param><key>samples_per_second</key><value>baud_rate*samples_per_symbol</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>Descrambler_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Descrambler_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>InfiniteAverage_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>receivedSignalConstellation</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>InfiniteAverage_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channelNoise</source_block_id><sink_block_id>noiseAdder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>Descrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>throttle</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guidedScrambler</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guidedScrambler</source_block_id><sink_block_id>pulseGenerator</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>matchedFilter</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noiseAdder</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noiseAdder</source_block_id><sink_block_id>matchedFilter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pulseGenerator</source_block_id><sink_block_id>throttle</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbolGenerator</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbolGenerator</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbolGenerator</source_block_id><sink_block_id>guidedScrambler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>throttle</source_block_id><sink_block_id>noiseAdder</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
