<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gs_demo</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>augmentingLength</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>autocovarianceLength</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baudRate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>codewordLength</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable_gr_gs_defaultConstellation</key>
<param><key>id</key><value>constellation</value></param>
<param><key>fieldSize</key><value>fieldSize</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constellationObj</value></param>
<param><key>const_points</key><value>constellation</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>0</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>range(fieldSize)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>continuous</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>distributionSize</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fieldSize</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frameLength</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noisePower</value></param>
<param><key>value</key><value>0.1875</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrcTaps</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>ntaps</key><value>4096</value></param>
<param><key>samp_rate</key><value>baudRate*samplesPerSymbol</value></param>
<param><key>sym_rate</key><value>baudRate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samplesPerSymbol</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_gr_gs_defaultScrambler</key>
<param><key>id</key><value>scramblingPolynomial</value></param>
<param><key>augmentingLength</key><value>augmentingLength</value></param>
<param><key>codewordLength</key><value>codewordLength</value></param>
<param><key>fieldSize</key><value>fieldSize</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>windowSize</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>gr_gs_Autocovariance</key>
<param><key>id</key><value>autocovariance</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>length</key><value>autocovarianceLength</value></param>
<param><key>mean</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>sampleType</key><value>complex</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>autocovarianceXXaverage</value></param>
<param><key>decimation</key><value>512</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>autocovarianceLength</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>autocovarianceXYaverage</value></param>
<param><key>decimation</key><value>512</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>autocovarianceLength</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>autocovarianceYXaverage</value></param>
<param><key>decimation</key><value>512</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>autocovarianceLength</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>autocovarianceYYaverage</value></param>
<param><key>decimation</key><value>512</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>autocovarianceLength</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>channelNoise</value></param>
<param><key>amp</key><value>math.sqrt(noisePower)</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>constellationDecoder</value></param>
<param><key>constellation</key><value>constellationObj</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>constellationDecoderMultiplier</value></param>
<param><key>const</key><value>constellationObj.points()[0].real/constellation[0].real</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_gs_Descrambler</key>
<param><key>id</key><value>descrambler</value></param>
<param><key>augmentingLength</key><value>augmentingLength</value></param>
<param><key>codewordLength</key><value>codewordLength</value></param>
<param><key>continuous</key><value>continuous</value></param>
<param><key>fieldSize</key><value>fieldSize</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>multiplier</key><value>scramblingPolynomial</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>gr_gs_Distribution</key>
<param><key>id</key><value>distribution</value></param>
<param><key>leastBinCenter</key><value>-distributionSize*(1+1j)/2</value></param>
<param><key>decimation</key><value>512</value></param>
<param><key>bins</key><value>distributionSize</value></param>
<param><key>sampleType</key><value>complex</value></param>
<param><key>binSize</key><value>1</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>distributionLog10</value></param>
<param><key>vlen</key><value>distributionSize</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>gr_gs_Entropy</key>
<param><key>id</key><value>entropy</value></param>
<param><key>augmentingLength</key><value>augmentingLength</value></param>
<param><key>codewordLength</key><value>codewordLength</value></param>
<param><key>fieldSize</key><value>fieldSize</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>minCorrelation</key><value>0.001</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>entropyAverage</value></param>
<param><key>decimation</key><value>256</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>1</value></param>
</block>
<block>
<key>gr_gs_ErrorCount</key>
<param><key>id</key><value>errorCount</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>maxErrors</key><value>0</value></param>
<param><key>maxSymbols</key><value>0</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>gr_gs_ErrorCount</key>
<param><key>id</key><value>errorCount_0</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>maxErrors</key><value>0</value></param>
<param><key>maxSymbols</key><value>0</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>gr_gs_ErrorCount</key>
<param><key>id</key><value>errorCount_0_0</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>maxErrors</key><value>0</value></param>
<param><key>maxSymbols</key><value>0</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>errorRateLog10</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>errorRateLog10_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>errorRateLog10_0_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>fftVectorizer</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>windowSize</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>firdesImport_0</value></param>
<param><key>import</key><value>import math, numpy</value></param>
</block>
<block>
<key>gr_gs_Detector</key>
<param><key>id</key><value>gr_gs_Detector_0</value></param>
<param><key>augmentingLength</key><value>augmentingLength</value></param>
<param><key>codewordLength</key><value>codewordLength</value></param>
<param><key>fieldSize</key><value>fieldSize</value></param>
<param><key>framingTag</key><value></value></param>
<param><key>minCorrelation</key><value>0.01</value></param>
<param><key>noisePower</key><value>noisePower</value></param>
<param><key>symbolType</key><value>byte</value></param>
<param><key>windowSize</key><value>128</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>guiAutocovariance</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Rxx(t)</value></param>
<param><key>label2</key><value>Rxy(t)</value></param>
<param><key>label3</key><value>Ryx(t)</value></param>
<param><key>label4</key><value>Ryy(t)</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>autocovarianceLength</value></param>
<param><key>x_axis_label</key><value>"Relative symbol position"</value></param>
<param><key>x_start</key><value>-(autocovarianceLength-1)</value></param>
<param><key>x_step</key><value>1</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-0.25</value></param>
<param><key>y_axis_label</key><value>"RDS Covariance"</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>guiConstellation</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>numpy.max(numpy.real(constellation))+1</value></param>
<param><key>xmin</key><value>-numpy.max(numpy.real(constellation))-1</value></param>
<param><key>ymax</key><value>numpy.max(numpy.real(constellation))+1</value></param>
<param><key>ymin</key><value>-numpy.max(numpy.real(constellation))-1</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>guiDistribution</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>distributionSize</value></param>
<param><key>x_axis_label</key><value>"Re(RDS) when Im(RDS)=0"</value></param>
<param><key>x_start</key><value>-distributionSize/2</value></param>
<param><key>x_step</key><value>1</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-180</value></param>
<param><key>y_axis_label</key><value>"Probability (dB)"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>guiEntropy</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>math.log10(fieldSize)/math.log10(2)</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Entropy (bits/symbol)"</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>guiErrorRate</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-60</value></param>
<param><key>name</key><value>"Descrambled Error Rate (dB)"</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>guiErrorRate_0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-60</value></param>
<param><key>name</key><value>"MAP Error Rate (dB)"</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>guiErrorRate_0_0</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-60</value></param>
<param><key>name</key><value>"ML Error Rate (dB)"</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>guiPsd</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>vlen</key><value>windowSize</value></param>
<param><key>x_axis_label</key><value>"Frequency (kHz)"</value></param>
<param><key>x_start</key><value>-baudRate*samplesPerSymbol/2000</value></param>
<param><key>x_step</key><value>baudRate*samplesPerSymbol*1.0/(windowSize*1000)</value></param>
<param><key>x_units</key><value>"kHz"</value></param>
<param><key>y_axis_label</key><value>"Spectral Density (dBFS/Hz)"</value></param>
<param><key>y_units</key><value>"dB"</value></param>
</block>
<block>
<key>gr_gs_GuidedScrambler</key>
<param><key>id</key><value>guidedScrambler</value></param>
<param><key>augmentingLength</key><value>augmentingLength</value></param>
<param><key>codewordLength</key><value>codewordLength</value></param>
<param><key>constellation</key><value>constellation</value></param>
<param><key>continuous</key><value>continuous</value></param>
<param><key>divider</key><value>scramblingPolynomial</value></param>
<param><key>fieldSize</key><value>fieldSize</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>selectionMethod</key><value>MSW</value></param>
<param><key>symbolType</key><value>byte</value></param>
<param><key>threads</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>noiseAdder</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>psdAverage</value></param>
<param><key>decimation</key><value>16</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>windowSize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>psdFFT</value></param>
<param><key>fft_size</key><value>windowSize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.hanning(windowSize)</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>psdLog10</value></param>
<param><key>vlen</key><value>windowSize</value></param>
<param><key>k</key><value>-10*math.log10(baudRate * samplesPerSymbol).real</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>psdMag</value></param>
<param><key>vlen</key><value>windowSize</value></param>
</block>
<block>
<key>gr_gs_Integrate</key>
<param><key>id</key><value>rdsMapper</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>sampleType</key><value>complex</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>receiveFilter</value></param>
<param><key>decim</key><value>samplesPerSymbol</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>samp_delay</key><value>len(rrcTaps)/2</value></param>
<param><key>taps</key><value>rrcTaps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>gr_gs_SymbolGenerator</key>
<param><key>id</key><value>symbolGenerator</value></param>
<param><key>frameLength</key><value>frameLength*(codewordLength-augmentingLength)</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>symbolType</key><value>byte</value></param>
<param><key>weightings</key><value>[1] * fieldSize</value></param>
</block>
<block>
<key>gr_gs_SymbolMapper</key>
<param><key>id</key><value>symbolMapper</value></param>
<param><key>constellation</key><value>constellation</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>gr_gs_Terminator</key>
<param><key>id</key><value>terminator</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples</key><value>long(2e4)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>throttle</value></param>
<param><key>samples_per_second</key><value>baudRate*samplesPerSymbol</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>transmitFilter</value></param>
<param><key>interp</key><value>samplesPerSymbol</value></param>
<param><key>samp_delay</key><value>len(rrcTaps)/(samplesPerSymbol*2)</value></param>
<param><key>taps</key><value>rrcTaps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>autocovariance</source_block_id><sink_block_id>autocovarianceXXaverage</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>autocovariance</source_block_id><sink_block_id>autocovarianceXYaverage</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>autocovariance</source_block_id><sink_block_id>autocovarianceYXaverage</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>autocovariance</source_block_id><sink_block_id>autocovarianceYYaverage</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>autocovarianceXXaverage</source_block_id><sink_block_id>guiAutocovariance</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>autocovarianceXYaverage</source_block_id><sink_block_id>guiAutocovariance</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>autocovarianceYXaverage</source_block_id><sink_block_id>guiAutocovariance</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>autocovarianceYYaverage</source_block_id><sink_block_id>guiAutocovariance</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>channelNoise</source_block_id><sink_block_id>noiseAdder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>constellationDecoder</source_block_id><sink_block_id>errorCount_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>constellationDecoderMultiplier</source_block_id><sink_block_id>constellationDecoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>descrambler</source_block_id><sink_block_id>errorCount</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>distribution</source_block_id><sink_block_id>distributionLog10</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>distributionLog10</source_block_id><sink_block_id>guiDistribution</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>entropy</source_block_id><sink_block_id>entropyAverage</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>entropyAverage</source_block_id><sink_block_id>guiEntropy</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>errorCount</source_block_id><sink_block_id>errorRateLog10</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>errorCount_0</source_block_id><sink_block_id>errorRateLog10_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>errorCount_0_0</source_block_id><sink_block_id>errorRateLog10_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>errorRateLog10</source_block_id><sink_block_id>guiErrorRate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>errorRateLog10_0</source_block_id><sink_block_id>guiErrorRate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>errorRateLog10_0_0</source_block_id><sink_block_id>guiErrorRate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fftVectorizer</source_block_id><sink_block_id>psdFFT</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Detector_0</source_block_id><sink_block_id>descrambler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Detector_0</source_block_id><sink_block_id>errorCount_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>guidedScrambler</source_block_id><sink_block_id>entropy</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guidedScrambler</source_block_id><sink_block_id>errorCount_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guidedScrambler</source_block_id><sink_block_id>errorCount_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guidedScrambler</source_block_id><sink_block_id>symbolMapper</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guidedScrambler</source_block_id><sink_block_id>terminator</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noiseAdder</source_block_id><sink_block_id>fftVectorizer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noiseAdder</source_block_id><sink_block_id>receiveFilter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>psdAverage</source_block_id><sink_block_id>psdLog10</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>psdFFT</source_block_id><sink_block_id>psdMag</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>psdLog10</source_block_id><sink_block_id>guiPsd</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>psdMag</source_block_id><sink_block_id>psdAverage</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rdsMapper</source_block_id><sink_block_id>autocovariance</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rdsMapper</source_block_id><sink_block_id>distribution</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>receiveFilter</source_block_id><sink_block_id>constellationDecoderMultiplier</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>receiveFilter</source_block_id><sink_block_id>gr_gs_Detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>receiveFilter</source_block_id><sink_block_id>guiConstellation</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbolGenerator</source_block_id><sink_block_id>errorCount</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbolGenerator</source_block_id><sink_block_id>guidedScrambler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbolMapper</source_block_id><sink_block_id>rdsMapper</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbolMapper</source_block_id><sink_block_id>transmitFilter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>throttle</source_block_id><sink_block_id>noiseAdder</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>transmitFilter</source_block_id><sink_block_id>throttle</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
