<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gs_demo</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>GuidedScrambler</key>
<param><key>id</key><value>GuidedScrambler_0</value></param>
<param><key>augmentingLength</key><value>3</value></param>
<param><key>codewordLength</key><value>12</value></param>
<param><key>constellation</key><value>[1,1j,-1j,-1]</value></param>
<param><key>continuous</key><value>True</value></param>
<param><key>divider</key><value>[1,0,0,1]</value></param>
<param><key>fieldSize</key><value>4</value></param>
<param><key>selectionMethod</key><value>MSW</value></param>
<param><key>threads</key><value>0</value></param>
</block>
<block>
<key>PulseGenerator</key>
<param><key>id</key><value>PulseGenerator_0</value></param>
<param><key>amplitude</key><value>0.8</value></param>
<param><key>baudRate</key><value>baud_rate</value></param>
<param><key>constellation</key><value>[1,1j,-1j,-1]</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>phase</key><value>0.0</value></param>
<param><key>samplesPerSymbol</key><value>samples_per_symbol</value></param>
<param><key>shape</key><value>1</value></param>
<param><key>numberOfTaps</key><value>1024</value></param>
<param><key>tags</key><value>False</value></param>
</block>
<block>
<key>SymbolGenerator</key>
<param><key>id</key><value>SymbolGenerator_0</value></param>
<param><key>weightings</key><value>[1, 1, 1, 1]</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>baud_rate*samples_per_symbol</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>baud_rate*samples_per_symbol</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-30</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<connection><source_block_id>GuidedScrambler_0</source_block_id><sink_block_id>PulseGenerator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PulseGenerator_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SymbolGenerator_0</source_block_id><sink_block_id>GuidedScrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
