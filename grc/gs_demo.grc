<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gs_demo</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>augmentingLength</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>autocovarianceLength</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>codewordLength</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable_gr_gs_defaultConstellation</key>
<param><key>id</key><value>constellation</value></param>
<param><key>fieldSize</key><value>fieldSize</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constellationObj</value></param>
<param><key>const_points</key><value>constellation</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>range(fieldSize)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>continuous</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>distributionSize</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fieldSize</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frameLength</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rotation</value></param>
<param><key>value</key><value>math.pi/2</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrcTaps</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>ntaps</key><value>4096</value></param>
<param><key>samp_rate</key><value>baud_rate*samples_per_symbol</value></param>
<param><key>sym_rate</key><value>baud_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_gr_gs_defaultScrambler</key>
<param><key>id</key><value>scramblingPolynomial</value></param>
<param><key>fieldSize</key><value>fieldSize</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_size</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>window_size</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>window_size</value></param>
<param><key>k</key><value>-10*math.log10(baud_rate * samples_per_symbol).real</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_1</value></param>
<param><key>vlen</key><value>distributionSize</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_1_0_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>-rotation</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_1</value></param>
<param><key>phase_inc</key><value>rotation</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>window_size</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>channelNoise</value></param>
<param><key>amp</key><value>0.35</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>constellationObj</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1</value></param>
<param><key>decim</key><value>samples_per_symbol</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>samp_delay</key><value>len(rrcTaps)/2</value></param>
<param><key>taps</key><value>rrcTaps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>window_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(window_size)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>firdesImport_0</value></param>
<param><key>import</key><value>import math, numpy</value></param>
</block>
<block>
<key>gr_gs_Autocovariance</key>
<param><key>id</key><value>gr_gs_Autocovariance_0</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>length</key><value>autocovarianceLength</value></param>
<param><key>mean</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>sampleType</key><value>complex</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>gr_gs_Average_0</value></param>
<param><key>decimation</key><value>16</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>window_size</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>gr_gs_Average_1</value></param>
<param><key>decimation</key><value>512</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>autocovarianceLength</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>gr_gs_Average_1_0</value></param>
<param><key>decimation</key><value>512</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>autocovarianceLength</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>gr_gs_Average_1_1</value></param>
<param><key>decimation</key><value>512</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>autocovarianceLength</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>gr_gs_Average_1_2</value></param>
<param><key>decimation</key><value>512</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>autocovarianceLength</value></param>
</block>
<block>
<key>gr_gs_Average</key>
<param><key>id</key><value>gr_gs_Average_2</value></param>
<param><key>decimation</key><value>256</value></param>
<param><key>sampleType</key><value>float</value></param>
<param><key>vectorSize</key><value>1</value></param>
</block>
<block>
<key>gr_gs_Descrambler</key>
<param><key>id</key><value>gr_gs_Descrambler_0</value></param>
<param><key>augmentingLength</key><value>augmentingLength</value></param>
<param><key>codewordLength</key><value>codewordLength</value></param>
<param><key>continuous</key><value>continuous</value></param>
<param><key>fieldSize</key><value>fieldSize</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>multiplier</key><value>scramblingPolynomial</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>gr_gs_Distribution</key>
<param><key>id</key><value>gr_gs_Distribution_0</value></param>
<param><key>leastBinCenter</key><value>-distributionSize*(1+1j)/2</value></param>
<param><key>decimation</key><value>512</value></param>
<param><key>bins</key><value>distributionSize</value></param>
<param><key>sampleType</key><value>complex</value></param>
<param><key>binSize</key><value>1</value></param>
</block>
<block>
<key>gr_gs_Entropy</key>
<param><key>id</key><value>gr_gs_Entropy_0</value></param>
<param><key>augmentingLength</key><value>augmentingLength</value></param>
<param><key>codewordLength</key><value>codewordLength</value></param>
<param><key>fieldSize</key><value>fieldSize</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>minCorrelation</key><value>0.001</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>gr_gs_ErrorCount</key>
<param><key>id</key><value>gr_gs_ErrorCount_0</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>gr_gs_Integrate</key>
<param><key>id</key><value>gr_gs_Integrate_0_0</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>sampleType</key><value>complex</value></param>
</block>
<block>
<key>gr_gs_SymbolMapper</key>
<param><key>id</key><value>gr_gs_SymbolMapper_0</value></param>
<param><key>constellation</key><value>constellation</value></param>
<param><key>symbolType</key><value>byte</value></param>
</block>
<block>
<key>gr_gs_Terminator</key>
<param><key>id</key><value>gr_gs_Terminator_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples</key><value>long(1e7)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_gs_GuidedScrambler</key>
<param><key>id</key><value>guidedScrambler</value></param>
<param><key>augmentingLength</key><value>augmentingLength</value></param>
<param><key>codewordLength</key><value>codewordLength</value></param>
<param><key>constellation</key><value>constellation</value></param>
<param><key>continuous</key><value>continuous</value></param>
<param><key>divider</key><value>scramblingPolynomial</value></param>
<param><key>fieldSize</key><value>fieldSize</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>selectionMethod</key><value>MSW</value></param>
<param><key>symbolType</key><value>byte</value></param>
<param><key>threads</key><value>0</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>samples_per_symbol</value></param>
<param><key>samp_delay</key><value>len(rrcTaps)/(samples_per_symbol*2)</value></param>
<param><key>taps</key><value>rrcTaps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>noiseAdder</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-60</value></param>
<param><key>name</key><value>"Symbol Error Rate (dB)"</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>math.log10(fieldSize)/math.log10(2)</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Entropy (bits/symbol)"</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>vlen</key><value>window_size</value></param>
<param><key>x_axis_label</key><value>"Frequency (kHz)"</value></param>
<param><key>x_start</key><value>-baud_rate*samples_per_symbol/2000</value></param>
<param><key>x_step</key><value>baud_rate*samples_per_symbol*1.0/(window_size*1000)</value></param>
<param><key>x_units</key><value>"kHz"</value></param>
<param><key>y_axis_label</key><value>"Spectral Density (dBFS/Hz)"</value></param>
<param><key>y_units</key><value>"dB"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_1</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>distributionSize</value></param>
<param><key>x_axis_label</key><value>"Re(RDS) when Im(RDS)=0"</value></param>
<param><key>x_start</key><value>-distributionSize/2</value></param>
<param><key>x_step</key><value>1</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-180</value></param>
<param><key>y_axis_label</key><value>"Probability (dB)"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_1_0</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Rxx(t)</value></param>
<param><key>label2</key><value>Rxy(t)</value></param>
<param><key>label3</key><value>Ryx(t)</value></param>
<param><key>label4</key><value>Ryy(t)</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>autocovarianceLength</value></param>
<param><key>x_axis_label</key><value>"Relative symbol position"</value></param>
<param><key>x_start</key><value>-(autocovarianceLength-1)</value></param>
<param><key>x_step</key><value>1</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-0.25</value></param>
<param><key>y_axis_label</key><value>"RDS Covariance"</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>receivedSignalConstellation</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>numpy.max(numpy.real(constellation))+1</value></param>
<param><key>xmin</key><value>-numpy.max(numpy.real(constellation))-1</value></param>
<param><key>ymax</key><value>numpy.max(numpy.real(constellation))+1</value></param>
<param><key>ymin</key><value>-numpy.max(numpy.real(constellation))-1</value></param>
</block>
<block>
<key>gr_gs_SymbolGenerator</key>
<param><key>id</key><value>symbolGenerator</value></param>
<param><key>frameLength</key><value>frameLength*(codewordLength-augmentingLength)</value></param>
<param><key>framingTag</key><value>frame</value></param>
<param><key>symbolType</key><value>byte</value></param>
<param><key>weightings</key><value>[1] * fieldSize</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>throttle</value></param>
<param><key>samples_per_second</key><value>baud_rate*samples_per_symbol</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>gr_gs_Average_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_1</source_block_id><sink_block_id>qtgui_vector_sink_f_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_1_0_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>receivedSignalConstellation</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channelNoise</source_block_id><sink_block_id>noiseAdder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>gr_gs_Descrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Autocovariance_0</source_block_id><sink_block_id>gr_gs_Average_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Autocovariance_0</source_block_id><sink_block_id>gr_gs_Average_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Autocovariance_0</source_block_id><sink_block_id>gr_gs_Average_1_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Autocovariance_0</source_block_id><sink_block_id>gr_gs_Average_1_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Average_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Average_1</source_block_id><sink_block_id>qtgui_vector_sink_f_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Average_1_0</source_block_id><sink_block_id>qtgui_vector_sink_f_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_gs_Average_1_1</source_block_id><sink_block_id>qtgui_vector_sink_f_1_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>gr_gs_Average_1_2</source_block_id><sink_block_id>qtgui_vector_sink_f_1_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>gr_gs_Average_2</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Descrambler_0</source_block_id><sink_block_id>gr_gs_ErrorCount_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_gs_Distribution_0</source_block_id><sink_block_id>blocks_nlog10_ff_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Entropy_0</source_block_id><sink_block_id>gr_gs_Average_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_ErrorCount_0</source_block_id><sink_block_id>blocks_nlog10_ff_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Integrate_0_0</source_block_id><sink_block_id>gr_gs_Autocovariance_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_Integrate_0_0</source_block_id><sink_block_id>gr_gs_Distribution_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_SymbolMapper_0</source_block_id><sink_block_id>blocks_rotator_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_gs_SymbolMapper_0</source_block_id><sink_block_id>gr_gs_Integrate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guidedScrambler</source_block_id><sink_block_id>gr_gs_Entropy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guidedScrambler</source_block_id><sink_block_id>gr_gs_SymbolMapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guidedScrambler</source_block_id><sink_block_id>gr_gs_Terminator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>throttle</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noiseAdder</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noiseAdder</source_block_id><sink_block_id>fft_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbolGenerator</source_block_id><sink_block_id>gr_gs_ErrorCount_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbolGenerator</source_block_id><sink_block_id>guidedScrambler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>throttle</source_block_id><sink_block_id>noiseAdder</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
